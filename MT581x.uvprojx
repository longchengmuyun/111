# Keil uVision project MT581x.uvprojx, settings and files
target release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: MT581x +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\scatter.scat
  link misc: --no_startup --entry=main
  group src
    ./src/: startup.s main.c interrupt.c app.c adc.c fpwm.c led.c misc.c adapter.c proprietary.c fod.c wpc.c
  group maxic
    ./src/: MT581x.lib
